<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\STM32L4 SPI Bootloader host.ewp</path>
  </project>
  <batchBuild />
</workspace>
